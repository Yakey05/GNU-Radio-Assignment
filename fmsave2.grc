<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_digital_rf_digital_rf_sink</key>
<param><key>id</key><value>gr_digital_rf_digital_rf_sink_0</value></param>
<param><key>metadata</key><value>{}</value></param>
<param><key>center_freqs</key><value></value></param>
<param><key>channel0</key><value>ch0</value></param>
<param><key>is_continuous</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>top_level_dir</key><value>/media/pi/KD8OXT</value></param>
<param><key>file_cadence_ms</key><value>1000</value></param>
<param><key>checksum</key><value>False</value></param>
<param><key>compression_level</key><value>0</value></param>
<param><key>ignore_tags</key><value>False</value></param>
<param><key>input</key><value>fc32</value></param>
<param><key>marching_periods</key><value>True</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate_denominator</key><value>1</value></param>
<param><key>sample_rate_numerator</key><value>int(samp_rate)</value></param>
<param><key>start</key><value>'now'</value></param>
<param><key>stop_on_skipped</key><value>False</value></param>
<param><key>stop_on_time_tag</key><value>False</value></param>
<param><key>subdir_cadence_s</key><value>3600</value></param>
<param><key>uuid</key><value></value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>90e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>2e6</value></param>
<param><key>freq0</key><value>90e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
